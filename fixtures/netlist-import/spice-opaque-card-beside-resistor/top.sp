* opaque
R0 a 0 1k
A1 a b xmod
.end
